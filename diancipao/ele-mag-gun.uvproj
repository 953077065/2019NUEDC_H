# Keil uVision project ele-mag-gun.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64S4A12 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: ele-mag-gun +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c Lcd1602.h keyboard.h pwm.h
